# Keil uVision project Project.uvprojx, settings and files
target STM32RTOS (6180000::V6.18::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: .\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./source/: main.c boardkey.c boardled.c serial.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS:Keil RTX5 5.5.4, CMSIS:RTOS2:Keil RTX5 5.5.4, CMSIS Driver:USART 2.3, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:IWDG 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0, Device:StdPeriph Drivers:WWDG 3.6.0
